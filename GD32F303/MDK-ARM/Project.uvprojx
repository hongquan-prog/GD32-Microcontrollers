# Keil uVision project Project.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F303CC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20017FFF)IROM(0x08000000-0x080FFFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: GD32103B_START +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD,ARM_MATH_CM4
  c include: ..\..\Drivers\GD32F30x_standard_peripheral\Include;..\..\Drivers\CMSIS\GD\GD32F30x\Include;..\..\Drivers\CMSIS\Include;..\..\Drivers\CMSIS;..\Core\Inc;..\..\Middlewares\FreeRTOS\Source\include;..\..\Middlewares\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\Middlewares\FreeRTOS\Source\portable\MemMang;..\..\Middlewares\FreeRTOS\Source\CMSIS_RTOS_V2\ARM_CM4
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Core
    ../Core/Src/: gd32f30x_it.c main.c freertos.c gpio.c dma.c err.c
  group Drivers/CMSIS
    ../../Drivers/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group Drivers/GD32F30x_Peripherals
    ../../Drivers/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group MDK-ARM
    ../../Drivers/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
  group Middlewares/FreeRTOS
    ../../Middlewares/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../Middlewares/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../Middlewares/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../Middlewares/FreeRTOS/Source/CMSIS_RTOS_V2/ARM_CM4/: cmsis_os2.c

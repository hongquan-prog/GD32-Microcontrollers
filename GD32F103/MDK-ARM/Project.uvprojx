# Keil uVision project Project.uvprojx, settings and files
target Project (6160000::V6.16::ARMCLANG)
  device: GD32F103C8 GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.2
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x08000000-0x0803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: GD32103B_START +hex
  c flags: OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F10X_MD
  c include: ..\Middlewares\DSP\Include;..\..\Middlewares\FreeRTOS\Source\portable\GCC\ARM_CM3;..\..\Middlewares\FreeRTOS\Source\CMSIS_RTOS_V2\ARM_CM3;..\..\Middlewares\FreeRTOS\Source\include;..\..\Drivers\CMSIS\Include;..\..\Drivers\CMSIS\GD\GD32F10x\Include;..\..\Drivers\GD32F10x_standard_peripheral\Include;..\Core\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group MDK-ARM
    ../../Drivers/CMSIS/GD/GD32F10x/Source/ARM/: startup_gd32f10x_md.s
  group Core
    ../Core/src/: main.c gd32f10x_it.c freertos.c err.c exti.c dma.c
  group Drivers/CMSIS
    ../../Drivers/CMSIS/GD/GD32F10x/Source/: system_gd32f10x.c
  group Drivers/GD32F10x_Peripherals
    ../../Drivers/GD32F10x_standard_peripheral/Source/: gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dbg.c gd32f10x_dma.c gd32f10x_enet.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_fwdgt.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdgt.c
  group Middlewares/FreeRTOS
    ../../Middlewares/FreeRTOS/Source/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c croutine.c
    ../../Middlewares/FreeRTOS/Source/CMSIS_RTOS_V2/ARM_CM3/: cmsis_os2.c
    ../../Middlewares/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../Middlewares/FreeRTOS/Source/portable/GCC/ARM_CM3/: port.c
  group Middlewares/DSP
    ../../Middlewares/DSP/Source/: cr4_fft_64_stm32.s cr4_fft_256_stm32.s

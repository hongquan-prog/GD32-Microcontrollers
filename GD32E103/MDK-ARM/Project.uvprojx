# Keil uVision project Project.uvprojx, settings and files
target Project (6160000::V6.16::ARMCLANG)
  device: GD32E103C8 GigaDevice
  pack: GigaDevice.GD32E10x_DFP.1.0.3
  cpu: IRAM(0x20000000-0x20004FFF)IROM(0x08000000-0x0800FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32E10X
  c include: ..\Middlewares\DSP\Include;..\..\Middlewares\FreeRTOS\Source\include;..\..\Middlewares\FreeRTOS\Source\portable\GCC\ARM_CM4F;..\..\Middlewares\FreeRTOS\Source\CMSIS_RTOS_V2\ARM_CM4;..\Core\inc;..\..\Drivers\CMSIS\Include;..\..\Drivers\CMSIS\GD\GD32E10x\Include;..\..\Drivers\GD32E10x_standard_peripheral\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Core
    ../Core/src/: main.c gd32e10x_it.c freertos.c
  group Drivers/CMSIS
    ../../Drivers/CMSIS/GD/GD32E10x/Source/: system_gd32e10x.c
  group Drivers/GD32E10x_Peripherals
    ../../Drivers/GD32E10x_standard_peripheral/Source/: gd32e10x_adc.c gd32e10x_bkp.c gd32e10x_crc.c gd32e10x_ctc.c gd32e10x_dac.c gd32e10x_dbg.c gd32e10x_dma.c gd32e10x_exmc.c gd32e10x_exti.c gd32e10x_fmc.c gd32e10x_fwdgt.c gd32e10x_gpio.c gd32e10x_i2c.c gd32e10x_misc.c gd32e10x_pmu.c gd32e10x_rcu.c gd32e10x_rtc.c gd32e10x_spi.c gd32e10x_timer.c gd32e10x_usart.c gd32e10x_wwdgt.c
  group MDK-ARM
    ../../Drivers/CMSIS/GD/GD32E10x/Source/ARM/: startup_gd32e10x.s
  group Middlewares/FreeRTOS
    ../../Middlewares/FreeRTOS/Source/: list.c queue.c stream_buffer.c tasks.c timers.c event_groups.c croutine.c
    ../../Middlewares/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../Middlewares/FreeRTOS/Source/CMSIS_RTOS_V2/ARM_CM4/: cmsis_os2.c
    ../../Middlewares/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c

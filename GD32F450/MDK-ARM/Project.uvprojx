# Keil uVision project Project.uvprojx, settings and files
target GD32450V_START (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F450VK GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x08000000-0x082FFFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F450
  c include: ..\..\Drivers\CMSIS\GD\GD32F4xx\Include;..\Core\Inc;..\..\Middlewares\FreeRTOS\Source\include;..\..\Middlewares\FreeRTOS\Source\CMSIS_RTOS_V2\ARM_CM4;..\..\Middlewares\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\Drivers\CMSIS\Include;..\..\Drivers\GD32F4xx_standard_peripheral\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ../Core/Src/: freertos.c gd32f4xx_it.c main.c systick.c
  group Drivers/CMSIS
    ../../Drivers/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group Drivers/GD32F4xx_Peripherals
    ../../Drivers/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group Startup
    ../../Drivers/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450.s
  group Middlewares/FreeRTOS
    ../../Middlewares/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../Middlewares/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../Middlewares/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../Middlewares/FreeRTOS/Source/CMSIS_RTOS_V2/ARM_CM4/: cmsis_os2.c
